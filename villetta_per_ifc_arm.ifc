Properties of the parts of a building model (IFC2X3)

# File

# IfcSite, Default Site
RefElevation: 0 m

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (m)
Piano 2 | 6.4
Piano 1 | 3.2
Piano 3 | 1.3
Piano 0 | 0

# IfcReinforcingBar (222)
BarSurface: TEXTURED; Material: B450C
Name | In | NominalDiameter (m) | BarLength (m) | BarRole
Arm Superiore; Trave:2 [Piano:0] | Piano 0 | 0.014 | 85.767 | MAIN
Arm Inferiore; Trave:2 [Piano:0] | Piano 0 | 0.014 | 105.203 | MAIN
Arm Staffa; Trave:1 [Piano:0] | Piano 0 | 0.008 | 162.582 | SHEAR
Arm Staffa; Trave:2 [Piano:0] | Piano 0 | 0.008 | 219.593 | SHEAR
Arm Generica; Trave:1 [Piano:0] | Piano 0 | 0.012 | 21.6649
Arm Generica; Trave:2 [Piano:0] | Piano 0 | 0.012 | 26.0649
Arm Superiore; Trave:4 [Piano:0] | Piano 0 | 0.014 | 85.792 | MAIN
Arm Inferiore; Trave:4 [Piano:0] | Piano 0 | 0.014 | 105.228 | MAIN
Arm Staffa; Trave:3 [Piano:0] | Piano 0 | 0.008 | 164.695 | SHEAR
Arm Staffa; Trave:4 [Piano:0] | Piano 0 | 0.008 | 203.124 | SHEAR
Arm Generica; Trave:3 [Piano:0] | Piano 0 | 0.012 | 21.6756
Arm Generica; Trave:4 [Piano:0] | Piano 0 | 0.012 | 26.0756
Arm Superiore; Trave:6 [Piano:0] | Piano 0 | 0.014 | 85.792 | MAIN
Arm Inferiore; Trave:6 [Piano:0] | Piano 0 | 0.014 | 105.228 | MAIN
Arm Staffa; Trave:5 [Piano:0] | Piano 0 | 0.008 | 164.695 | SHEAR
Arm Staffa; Trave:6 [Piano:0] | Piano 0 | 0.008 | 203.124 | SHEAR
Arm Generica; Trave:5 [Piano:0] | Piano 0 | 0.012 | 21.6756
Arm Generica; Trave:6 [Piano:0] | Piano 0 | 0.012 | 26.0756
Arm Superiore; Trave:7 [Piano:0] | Piano 0 | 0.014 | 72.967 | MAIN
Arm Inferiore; Trave:7 [Piano:0] | Piano 0 | 0.014 | 90.803 | MAIN
Arm Staffa; Trave:7 [Piano:0] | Piano 0 | 0.008 | 157.163 | SHEAR
Arm Staffa; Trave:8 [Piano:0] | Piano 0 | 0.008 | 142.736 | SHEAR
Arm Generica; Trave:7 [Piano:0] | Piano 0 | 0.012 | 21.6649
Arm Generica; Trave:8 [Piano:0] | Piano 0 | 0.012 | 19.6649
Arm Superiore; Trave:9 [Piano:0] | Piano 0 | 0.014 | 72.992 | MAIN
Arm Inferiore; Trave:9 [Piano:0] | Piano 0 | 0.014 | 90.828 | MAIN
Arm Staffa; Trave:9 [Piano:0] | Piano 0 | 0.008 | 164.695 | SHEAR
Arm Staffa; Trave:11 [Piano:0] | Piano 0 | 0.008 | 148.225 | SHEAR
Arm Generica; Trave:9 [Piano:0] | Piano 0 | 0.012 | 21.6756
Arm Generica; Trave:11 [Piano:0] | Piano 0 | 0.012 | 19.6756
Arm Superiore; Trave:12 [Piano:0] | Piano 0 | 0.014 | 72.967 | MAIN
Arm Superiore; Trave:14 [Piano:0] | Piano 0 | 0.014 | 2.54 | MAIN
Arm Inferiore; Trave:14 [Piano:0] | Piano 0 | 0.014 | 2.54 | MAIN
Arm Inferiore; Trave:12 [Piano:0] | Piano 0 | 0.014 | 90.803 | MAIN
Arm Staffa; Trave:10 [Piano:0] | Piano 0 | 0.008 | 38.4288 | SHEAR
Arm Staffa; Trave:13 [Piano:0] | Piano 0 | 0.008 | 93.3271 | SHEAR
Arm Staffa; Trave:14 [Piano:0] | Piano 0 | 0.008 | 43.9186 | SHEAR
Arm Staffa; Trave:12 [Piano:0] | Piano 0 | 0.008 | 142.736 | SHEAR
Arm Generica; Trave:10 [Piano:0] | Piano 0 | 0.012 | 10.8813
Arm Generica; Trave:13 [Piano:0] | Piano 0 | 0.012 | 12.6153
Arm Generica; Trave:14 [Piano:0] | Piano 0 | 0.012 | 16.5382
Arm Generica; Trave:12 [Piano:0] | Piano 0 | 0.012 | 19.6756
Arm Superiore; Trave:1 [Piano:3] | Piano 3 | 0.014 | 12.3695 | MAIN
Arm Inferiore; Trave:4 [Piano:3] | Piano 3 | 0.014 | 6.24001 | MAIN
Arm Inferiore; Trave:1 [Piano:3] | Piano 3 | 0.014 | 13.6353 | MAIN
Arm Staffa; Trave:5 [Piano:3] | Piano 3 | 0.008 | 7.25852 | SHEAR
Arm Staffa; Trave:4 [Piano:3] | Piano 3 | 0.008 | 8.71443 | SHEAR
Arm Staffa; Trave:1 [Piano:3] | Piano 3 | 0.008 | 22.9853 | SHEAR
Arm Generica; Trave:1 [Piano:3] | Piano 3 | 0.012 | 12.9638
Arm Superiore; Trave:3 [Piano:3] | Piano 3 | 0.014 | 48.3177 | MAIN
Arm Superiore; Trave:2 [Piano:3] | Piano 3 | 0.014 | 19.0742 | MAIN
Arm Inferiore; Trave:11 [Piano:1] | Piano 1 | 0.014 | 16.1538 | MAIN
Arm Inferiore; Trave:3 [Piano:3] | Piano 3 | 0.014 | 51.1163 | MAIN
Arm Staffa; Trave:11 [Piano:1] | Piano 1 | 0.008 | 53.7771 | SHEAR
Arm Staffa; Trave:3 [Piano:3] | Piano 3 | 0.008 | 164.41 | SHEAR
Arm Staffa; Trave:2 [Piano:3] | Piano 3 | 0.008 | 71.9295 | SHEAR
Arm Staffa; Pilastro:11 [Piano:3] | Piano 3 | 0.008 | 19.2687 | SHEAR
Arm Spillo; Pilastro:11 [Piano:3] | Piano 3 | 0.008 | 19.4453 | LIGATURE
Arm Principale; Pilastro:11 [Piano:3] | Piano 3 | 0.014 | 16.7599 | MAIN
Arm Ancoraggio; Nodo:11 [Piano:0] | Piano 0 | 0.014 | 21.1999
Arm Superiore; Trave:2 [Piano:1] | Piano 1 | 0.018 | 31.9668 | MAIN
Arm Superiore; Trave:1 [Piano:1] | Piano 1 | 0.018 | 12.823 | MAIN
Arm Inferiore; Trave:1 [Piano:1] | Piano 1 | 0.014 | 3.67 | MAIN
Arm Inferiore; Trave:2 [Piano:1] | Piano 1 | 0.014 | 42.3516 | MAIN
Arm Staffa; Trave:1 [Piano:1] | Piano 1 | 0.008 | 46.184 | SHEAR
Arm Staffa; Trave:2 [Piano:1] | Piano 1 | 0.008 | 47.2746 | SHEAR
Arm Generica; Trave:1 [Piano:1] | Piano 1 | 0.012 | 30.302
Arm Generica; Trave:2 [Piano:1] | Piano 1 | 0.012 | 12.2864
Arm Superiore; Trave:4 [Piano:1] | Piano 1 | 0.014 | 63.5463 | MAIN
Arm Inferiore; Trave:4 [Piano:1] | Piano 1 | 0.014 | 63.5463 | MAIN
Arm Staffa; Trave:3 [Piano:1] | Piano 1 | 0.008 | 106.814 | SHEAR
Arm Staffa; Trave:4 [Piano:1] | Piano 1 | 0.008 | 129.656 | SHEAR
Arm Superiore; Trave:6 [Piano:1] | Piano 1 | 0.014 | 44.6362 | MAIN
Arm Inferiore; Trave:6 [Piano:1] | Piano 1 | 0.014 | 42.3767 | MAIN
Arm Staffa; Trave:5 [Piano:1] | Piano 1 | 0.008 | 38.1247 | SHEAR
Arm Staffa; Trave:6 [Piano:1] | Piano 1 | 0.008 | 47.2746 | SHEAR
Arm Generica; Trave:5 [Piano:1] | Piano 1 | 0.012 | 10.1078
Arm Generica; Trave:6 [Piano:1] | Piano 1 | 0.012 | 12.3078
Arm Superiore; Trave:7 [Piano:1] | Piano 1 | 0.014 | 39.8916 | MAIN
Arm Inferiore; Trave:7 [Piano:1] | Piano 1 | 0.014 | 35.9516 | MAIN
Arm Staffa; Trave:7 [Piano:1] | Piano 1 | 0.008 | 35.7553 | SHEAR
Arm Staffa; Trave:8 [Piano:1] | Piano 1 | 0.008 | 33.5497 | SHEAR
Arm Generica; Trave:7 [Piano:1] | Piano 1 | 0.012 | 10.0864
Arm Generica; Trave:8 [Piano:1] | Piano 1 | 0.012 | 9.08636
Arm Superiore; Trave:10 [Piano:1] | Piano 1 | 0.014 | 35.9516 | MAIN
Arm Superiore; Trave:16 [Piano:1] | Piano 1 | 0.014 | 9.92914 | MAIN
Arm Inferiore; Trave:10 [Piano:1] | Piano 1 | 0.014 | 35.9516 | MAIN
Arm Staffa; Trave:9 [Piano:1] | Piano 1 | 0.008 | 25.9248 | SHEAR
Arm Staffa; Trave:16 [Piano:1] | Piano 1 | 0.008 | 27.4497 | SHEAR
Arm Staffa; Trave:10 [Piano:1] | Piano 1 | 0.008 | 33.5497 | SHEAR
Arm Generica; Trave:9 [Piano:1] | Piano 1 | 0.012 | 5.08636
Arm Generica; Trave:16 [Piano:1] | Piano 1 | 0.012 | 6.30764
Arm Generica; Trave:10 [Piano:1] | Piano 1 | 0.012 | 9.10782
Arm Superiore; Trave:13 [Piano:1] | Piano 1 | 0.014 | 71.9367 | MAIN
Arm Superiore; Trave:14 [Piano:1] | Piano 1 | 0.014 | 2.87 | MAIN
Arm Superiore; Trave:12 [Piano:1] | Piano 1 | 0.014 | 9.04031 | MAIN
Arm Superiore; Trave:14 [Piano:1] | Piano 1 | 0.014 | 22.6636 | MAIN
Arm Inferiore; Trave:12 [Piano:1] | Piano 1 | 0.014 | 9.40779 | MAIN
Arm Inferiore; Trave:14 [Piano:1] | Piano 1 | 0.014 | 4.5227 | MAIN
Arm Inferiore; Trave:13 [Piano:1] | Piano 1 | 0.014 | 71.9367 | MAIN
Arm Staffa; Trave:12 [Piano:1] | Piano 1 | 0.008 | 96.7988 | SHEAR
Arm Staffa; Trave:15 [Piano:1] | Piano 1 | 0.008 | 115.852 | SHEAR
Arm Staffa; Trave:14 [Piano:1] | Piano 1 | 0.008 | 61.5464 | SHEAR
Arm Staffa; Trave:13 [Piano:1] | Piano 1 | 0.008 | 137.574 | SHEAR
Arm Superiore; Trave:17 [Piano:1] | Piano 1 | 0.014 | 40.201 | MAIN
Arm Inferiore; Trave:17 [Piano:1] | Piano 1 | 0.014 | 38.6945 | MAIN
Arm Staffa; Trave:17 [Piano:1] | Piano 1 | 0.008 | 160.527 | SHEAR
Arm Staffa; Pilastro:1 [Piano:1] | Piano 1 | 0.008 | 42.6176 | SHEAR
Arm Spillo; Pilastro:1 [Piano:1] | Piano 1 | 0.008 | 42.3657 | LIGATURE
Arm Principale; Pilastro:1 [Piano:1] | Piano 1 | 0.014 | 47.6424 | MAIN
Arm Ancoraggio; Nodo:1 [Piano:0] | Piano 0 | 0.014 | 21.3
Arm Staffa; Pilastro:2 [Piano:1] | Piano 1 | 0.008 | 58.1658 | SHEAR
Arm Spillo; Pilastro:2 [Piano:1] | Piano 1 | 0.008 | 66.6105 | LIGATURE
Arm Principale; Pilastro:2 [Piano:1] | Piano 1 | 0.014 | 55.6147 | MAIN
Arm Ancoraggio; Nodo:2 [Piano:0] | Piano 0 | 0.014 | 24.85
Arm Staffa; Pilastro:3 [Piano:1] | Piano 1 | 0.008 | 42.6176 | SHEAR
Arm Spillo; Pilastro:3 [Piano:1] | Piano 1 | 0.008 | 42.3657 | LIGATURE
Arm Principale; Pilastro:3 [Piano:1] | Piano 1 | 0.014 | 47.6424 | MAIN
Arm Ancoraggio; Nodo:3 [Piano:0] | Piano 0 | 0.014 | 21.3
Arm Staffa; Pilastro:4 [Piano:1] | Piano 1 | 0.008 | 50.8133 | SHEAR
Arm Spillo; Pilastro:4 [Piano:1] | Piano 1 | 0.008 | 35.7366 | LIGATURE
Arm Principale; Pilastro:4 [Piano:1] | Piano 1 | 0.014 | 39.702 | MAIN
Arm Ancoraggio; Nodo:4 [Piano:0] | Piano 0 | 0.014 | 17.75
Arm Staffa; Pilastro:5 [Piano:1] | Piano 1 | 0.008 | 52.9372 | SHEAR
Arm Spillo; Pilastro:5 [Piano:1] | Piano 1 | 0.008 | 90.0725 | LIGATURE
Arm Principale; Pilastro:5 [Piano:1] | Piano 1 | 0.014 | 79.4078 | MAIN
Arm Ancoraggio; Nodo:5 [Piano:0] | Piano 0 | 0.014 | 35.5
Arm Staffa; Pilastro:6 [Piano:1] | Piano 1 | 0.008 | 50.8133 | SHEAR
Arm Spillo; Pilastro:6 [Piano:1] | Piano 1 | 0.008 | 35.7366 | LIGATURE
Arm Principale; Pilastro:6 [Piano:1] | Piano 1 | 0.014 | 47.6424 | MAIN
Arm Ancoraggio; Nodo:6 [Piano:0] | Piano 0 | 0.014 | 21.3
Arm Staffa; Pilastro:7 [Piano:1] | Piano 1 | 0.008 | 40.9785 | SHEAR
Arm Spillo; Pilastro:7 [Piano:1] | Piano 1 | 0.008 | 28.8199 | LIGATURE
Arm Principale; Pilastro:7 [Piano:1] | Piano 1 | 0.014 | 39.702 | MAIN
Arm Ancoraggio; Nodo:7 [Piano:0] | Piano 0 | 0.014 | 17.75
Arm Staffa; Pilastro:8 [Piano:1] | Piano 1 | 0.008 | 53.0174 | SHEAR
Arm Spillo; Pilastro:8 [Piano:1] | Piano 1 | 0.008 | 59.954 | LIGATURE
Arm Principale; Pilastro:8 [Piano:1] | Piano 1 | 0.014 | 55.6147 | MAIN
Arm Ancoraggio; Nodo:8 [Piano:0] | Piano 0 | 0.014 | 24.85
Arm Staffa; Pilastro:9 [Piano:1] | Piano 1 | 0.008 | 42.6176 | SHEAR
Arm Spillo; Pilastro:9 [Piano:1] | Piano 1 | 0.008 | 29.9727 | LIGATURE
Arm Principale; Pilastro:9 [Piano:1] | Piano 1 | 0.014 | 39.702 | MAIN
Arm Ancoraggio; Nodo:9 [Piano:0] | Piano 0 | 0.014 | 17.75
Arm Superiore; Trave:1 [Piano:2] | Piano 2 | 0.014 | 55.1728 | MAIN
Arm Superiore; Trave:21 [Piano:2] | Piano 2 | 0.014 | 24.6376 | MAIN
Arm Superiore; Trave:2 [Piano:2] | Piano 2 | 0.014 | 1.79 | MAIN
Arm Inferiore; Trave:1 [Piano:2] | Piano 2 | 0.014 | 41.9446 | MAIN
Arm Inferiore; Trave:2 [Piano:2] | Piano 2 | 0.014 | 42.5286 | MAIN
Arm Staffa; Trave:16 [Piano:2] | Piano 2 | 0.008 | 54.9327 | SHEAR
Arm Staffa; Trave:1 [Piano:2] | Piano 2 | 0.008 | 117.308 | SHEAR
Arm Staffa; Trave:13 [Piano:2] | Piano 2 | 0.008 | 18.5223 | SHEAR
Arm Staffa; Trave:2 [Piano:2] | Piano 2 | 0.008 | 128.176 | SHEAR
Arm Staffa; Trave:21 [Piano:2] | Piano 2 | 0.008 | 54.9327 | SHEAR
Arm Superiore; Trave:3 [Piano:2] | Piano 2 | 0.014 | 55.1854 | MAIN
Arm Superiore; Trave:20 [Piano:2] | Piano 2 | 0.014 | 24.6501 | MAIN
Arm Superiore; Trave:14 [Piano:2] | Piano 2 | 0.014 | 30.2222 | MAIN
Arm Superiore; Trave:4 [Piano:2] | Piano 2 | 0.014 | 8.18458 | MAIN
Arm Superiore; Trave:14 [Piano:2] | Piano 2 | 0.014 | 12.5284 | MAIN
Arm Inferiore; Trave:14 [Piano:2] | Piano 2 | 0.014 | 8.92627 | MAIN
Arm Inferiore; Trave:4 [Piano:2] | Piano 2 | 0.014 | 12.6521 | MAIN
Arm Inferiore; Trave:3 [Piano:2] | Piano 2 | 0.014 | 41.9571 | MAIN
Arm Inferiore; Trave:4 [Piano:2] | Piano 2 | 0.014 | 42.5412 | MAIN
Arm Staffa; Trave:17 [Piano:2] | Piano 2 | 0.008 | 55.567 | SHEAR
Arm Staffa; Trave:3 [Piano:2] | Piano 2 | 0.008 | 114.221 | SHEAR
Arm Staffa; Trave:14 [Piano:2] | Piano 2 | 0.008 | 15.4353 | SHEAR
Arm Staffa; Trave:4 [Piano:2] | Piano 2 | 0.008 | 129.656 | SHEAR
Arm Staffa; Trave:20 [Piano:2] | Piano 2 | 0.008 | 55.567 | SHEAR
Arm Superiore; Trave:5 [Piano:2] | Piano 2 | 0.014 | 55.1854 | MAIN
Arm Superiore; Trave:19 [Piano:2] | Piano 2 | 0.014 | 24.6501 | MAIN
Arm Superiore; Trave:5 [Piano:2] | Piano 2 | 0.014 | 3.10664 | MAIN
Arm Superiore; Trave:15 [Piano:2] | Piano 2 | 0.014 | 31.15 | MAIN
Arm Superiore; Trave:6 [Piano:2] | Piano 2 | 0.014 | 22.0931 | MAIN
Arm Superiore; Trave:15 [Piano:2] | Piano 2 | 0.014 | 5.32312 | MAIN
Arm Inferiore; Trave:6 [Piano:2] | Piano 2 | 0.014 | 11.82 | MAIN
Arm Inferiore; Trave:15 [Piano:2] | Piano 2 | 0.014 | 8.17357 | MAIN
Arm Inferiore; Trave:5 [Piano:2] | Piano 2 | 0.014 | 41.9571 | MAIN
Arm Inferiore; Trave:6 [Piano:2] | Piano 2 | 0.014 | 42.5412 | MAIN
Arm Staffa; Trave:18 [Piano:2] | Piano 2 | 0.008 | 55.567 | SHEAR
Arm Staffa; Trave:5 [Piano:2] | Piano 2 | 0.008 | 117.308 | SHEAR
Arm Staffa; Trave:15 [Piano:2] | Piano 2 | 0.008 | 18.5223 | SHEAR
Arm Staffa; Trave:6 [Piano:2] | Piano 2 | 0.008 | 129.656 | SHEAR
Arm Staffa; Trave:19 [Piano:2] | Piano 2 | 0.008 | 55.567 | SHEAR
Arm Generica; Trave:6 [Piano:2] | Piano 2 | 0.012 | 11.6519
Arm Superiore; Trave:7 [Piano:2] | Piano 2 | 0.014 | 47.4912 | MAIN
Arm Inferiore; Trave:7 [Piano:2] | Piano 2 | 0.014 | 47.451 | MAIN
Arm Staffa; Trave:7 [Piano:2] | Piano 2 | 0.008 | 71.533 | SHEAR
Arm Staffa; Trave:8 [Piano:2] | Piano 2 | 0.008 | 64.9944 | SHEAR
Arm Superiore; Trave:10 [Piano:2] | Piano 2 | 0.014 | 47.4912 | MAIN
Arm Inferiore; Trave:10 [Piano:2] | Piano 2 | 0.014 | 47.451 | MAIN
Arm Staffa; Trave:10 [Piano:2] | Piano 2 | 0.008 | 71.533 | SHEAR
Arm Staffa; Trave:9 [Piano:2] | Piano 2 | 0.008 | 64.9944 | SHEAR
Arm Superiore; Trave:11 [Piano:2] | Piano 2 | 0.014 | 57.0195 | MAIN
Arm Inferiore; Trave:11 [Piano:2] | Piano 2 | 0.014 | 56.9713 | MAIN
Arm Staffa; Trave:11 [Piano:2] | Piano 2 | 0.008 | 122.073 | SHEAR
Arm Staffa; Trave:12 [Piano:2] | Piano 2 | 0.008 | 114.221 | SHEAR
Arm Staffa; Pilastro:1 [Piano:2] | Piano 2 | 0.008 | 29.5045 | SHEAR
Arm Spillo; Pilastro:1 [Piano:2] | Piano 2 | 0.008 | 29.3301 | LIGATURE
Arm Principale; Pilastro:1 [Piano:2] | Piano 2 | 0.014 | 27.5599 | MAIN
Arm Staffa; Pilastro:2 [Piano:2] | Piano 2 | 0.008 | 43.3373 | SHEAR
Arm Spillo; Pilastro:2 [Piano:2] | Piano 2 | 0.008 | 41.3963 | LIGATURE
Arm Principale; Pilastro:2 [Piano:2] | Piano 2 | 0.014 | 38.3599 | MAIN
Arm Staffa; Pilastro:3 [Piano:2] | Piano 2 | 0.008 | 29.5045 | SHEAR
Arm Spillo; Pilastro:3 [Piano:2] | Piano 2 | 0.008 | 29.3301 | LIGATURE
Arm Principale; Pilastro:3 [Piano:2] | Piano 2 | 0.014 | 27.66 | MAIN
Arm Staffa; Pilastro:4 [Piano:2] | Piano 2 | 0.008 | 27.8654 | SHEAR
Arm Spillo; Pilastro:4 [Piano:2] | Piano 2 | 0.008 | 19.5975 | LIGATURE
Arm Principale; Pilastro:4 [Piano:2] | Piano 2 | 0.014 | 23.05 | MAIN
Arm Staffa; Pilastro:5 [Piano:2] | Piano 2 | 0.008 | 53.7391 | SHEAR
Arm Spillo; Pilastro:5 [Piano:2] | Piano 2 | 0.008 | 90.1809 | LIGATURE
Arm Principale; Pilastro:5 [Piano:2] | Piano 2 | 0.014 | 64.1 | MAIN
Arm Staffa; Pilastro:6 [Piano:2] | Piano 2 | 0.008 | 27.8654 | SHEAR
Arm Spillo; Pilastro:6 [Piano:2] | Piano 2 | 0.008 | 19.5975 | LIGATURE
Arm Principale; Pilastro:6 [Piano:2] | Piano 2 | 0.014 | 27.66 | MAIN
Arm Staffa; Pilastro:7 [Piano:2] | Piano 2 | 0.008 | 29.5045 | SHEAR
Arm Spillo; Pilastro:7 [Piano:2] | Piano 2 | 0.008 | 20.7503 | LIGATURE
Arm Principale; Pilastro:7 [Piano:2] | Piano 2 | 0.014 | 23.05 | MAIN
Arm Staffa; Pilastro:8 [Piano:2] | Piano 2 | 0.008 | 44.1393 | SHEAR
Arm Spillo; Pilastro:8 [Piano:2] | Piano 2 | 0.008 | 41.5042 | LIGATURE
Arm Principale; Pilastro:8 [Piano:2] | Piano 2 | 0.014 | 38.46 | MAIN
Arm Staffa; Pilastro:9 [Piano:2] | Piano 2 | 0.008 | 29.5045 | SHEAR
Arm Spillo; Pilastro:9 [Piano:2] | Piano 2 | 0.008 | 20.7503 | LIGATURE
Arm Principale; Pilastro:9 [Piano:2] | Piano 2 | 0.014 | 23.05 | MAIN
